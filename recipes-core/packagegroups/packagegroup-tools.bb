SUMMARY = "(MLD) tools group"
PR = "r1"

inherit packagegroup

RDEPENDS_${PN} = "\
    mc \
    htop \
    nano \
"
